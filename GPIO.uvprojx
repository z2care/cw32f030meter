# Keil uVision project GPIO.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER;.\hardware;.\libraries\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Driver
    ./libraries/src/: cw32f030_adc.c cw32f030_btim.c cw32f030_flash.c cw32f030_gpio.c cw32f030_pwr.c cw32f030_rcc.c cw32f030_systick.c cw32f030_uart.c system_cw32f030.c cw32f030_gtim.c
  group HardWare
    ./hardware/: ADC.c ADC.h BTIM1.c BTIM1.h Seg_Dis.c Seg_Dis.h flash.c UART3.c UART3.h PWR.c PWR.h Buzzer.c Buzzer.h
  group USER
    ./USER/: interrupts_cw32f030.c startup_cw32f030.s MAIN.c calibration.c calibration.h measurement.c measurement.h
    ./: readme.txt
software components: CMSIS:CORE 5.5.0
